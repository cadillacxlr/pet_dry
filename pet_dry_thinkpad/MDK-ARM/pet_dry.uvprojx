# Keil uVision project pet_dry.uvprojx, settings and files
target pet_dry (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: pet_dry
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;               ../Drivers/STM32F0xx_HAL_Driver/Inc;               ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;               ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;               ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_adc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c HT1602B.c NTC.c Key.c Disp_App.c Control.c
software components: CMSIS:CORE 5.0.1
